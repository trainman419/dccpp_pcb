# Repository trainman419/dccpp_pcb

File README.md:

# DCC++ PCB - All the parts for a basic DCC++ command station on a single PCB

This is the DCC++ board project. It's a relatively simple printed circuit board which integrates all of the components that are necessary for a DCC++ base station onto a single PCB, with all of the things you need, and nothing you don't.

Instead of the typical 1A limit of the arduino motor shield, this board uses the IFX007T half-bridge, with much larger current and voltage capability (up to 24V). Current capacity (without a heatsink) is probably around 5A, but may be more with proper ventilation or heatsinking.

The board is roughly based on the [Arduino Leonardo](https://www.arduino.cc/en/Main/Arduino_BoardLeonardo) and [Sparkfun's Pro Micro board](https://www.sparkfun.com/products/12640), but with the outputs already wired to the correct pins on IFX007T. The unused pins are available on screw terminals.

I designed this board to support the current and voltage needs of a G scale railroad, but it should work equally well for smaller scales.

The LEDs are connected to Arduino pins D1 and D2.

# Initial Programming

 * Attach an AVR ISP programming dongle, USBtiny, or other AVR programmer to your PC and board. (Make sure the drivers are installed).
 * Power on the DCC++ board by plugging in the micro USB cable.
 * Open the Arduino IDE
 * In the Tools menu, select "Arduino Leonardo" as the board type
 * In the Tools menu, select your programmer
 * In the Tools menu, select "Burn Bootloader"
 * Wait for the bootloader to complete. The board should show up as a serial port after the bootloader is flashed.
 * Clone my fork of the DCC++ project and load the DCCpp_Uno sketch onto the board.
 * Done!

## KiCad design dccpp_pcb.kicad_pcb

Parts:
C1: 10uF; CP_Elec_4x5.4; MPN 875105240001; Digi-Key_PN 732-6401-1-ND
C2, C6, C10, C11, C12, C13, C19, C20, C21, C22, C23, C24: 0.1uF 10V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN CL10B104KB8NNNC; Digi-Key_PN 1276-1000-1-ND
C3, C7: 1uF 10V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN CL10A105KP8NNNC; Digi-Key_PN 1276-1182-1-ND
C4, C5: 22pF 10V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN 06035A220JAT2A; Digi-Key_PN 478-1167-1-ND
C8, C9: 1000pF 10V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN CL10B102KB8NNNC; Digi-Key_PN 1276-1018-1-ND
C14: 100uF 30V; CP_Elec_10x10.5; MPN HHXC500ARA101MJA0G; Digi-Key_PN 565-4786-1-ND
C15, C16, C17, C18: 0.1uF 30V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN CL10B104KB8NNNC; Digi-Key_PN 1276-1000-1-ND
D1: LED (Yellow); LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN 150060YS55040; Digi-Key_PN 732-12018-1-ND
D2: LED (Green); LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN 150060VS55040; Digi-Key_PN 732-12017-1-ND
F1: 500mA cont / 1A trip; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; MPN 0ZCJ0050FF2G; Digi-Key_PN 507-1802-1-ND
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001; MPN 1050170001; Digi-Key_PN WM1399CT-ND
J2: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical; MPN 75869-331LF; Digi-Key_PN 609-5122-ND
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: OSTTC022162; Term_Block_1x2_P5.08MM; MPN OSTTC022162; Digi-Key_PN ED2609-ND
R1, R6, R9, R10, R11, R12, R13, R14, R15, R16: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN RNCP0603FTD10K0; Digi-Key_PN RNCP0603FTD10K0CT-ND
R2, R3: 22; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN RC0603FR-0722RL; Digi-Key_PN 311-22.0HRCT-ND
R4, R5: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN RC0603FR-07330RL; Digi-Key_PN 311-330HRCT-ND
R7, R8: 470; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN RC0603FR-07470RL; Digi-Key_PN 311-470HRCT-ND
R17, R18, R19, R20: 510; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN RC0603FR-07510RL; Digi-Key_PN 311-510HRCT-ND
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm; MPN ATMEGA32U4-AU; Digi-Key_PN ATMEGA32U4-AU-ND
U2: 74HC04; SOIC-14_3.9x8.7mm_P1.27mm; MPN MC74HC04ADG; Digi-Key_PN MC74HC04ADGOS-ND
U3, U4, U5, U6: IFX007T; TO-263-7_TabPin8; MPN IFX007TAUMA1; Digi-Key_PN IFX007TAUMA1CT-ND
Y1: 16MHz; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm_HandSoldering; MPN TSX-3225 16.0000MF09Z-AC0; Digi-Key_PN SER4069CT-ND

Connections:
+5V: C1.1, C2.2, C3.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, F1.1, J2.2 (VCC), R1.2, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC), U2.14 (VCC)
/A2: J4.1, U1.38 (PF5)
/A3: J4.2, U1.39 (PF4)
/A4: J3.1, U1.40 (PF1)
/A5: J3.2, U1.41 (PF0)
/D0: J9.1, U1.20 (PD2)
/D1: J9.2, U1.21 (PD3)
/D2: J8.1, U1.19 (PD1)
/D4: J8.2, U1.25 (PD4)
/D6: J7.1, U1.27 (PD7)
/D7: J7.2, U1.1 (PE6)
/D8: J6.1, U1.28 (PB4)
/D9: J6.2, U1.29 (PB5)
/D12: J5.1, U1.26 (PD6)
/D13: J5.2, U1.32 (PC7)
/MISO: J2.1 (MISO), U1.11 (PB3)
/MOSI: J2.4 (MOSI), U1.10 (PB2)
/OUT: R10.2, U1.30 (PB6), U2.13
/OUT_EN: R9.2, R11.2, U1.18 (PD0)
/OUT_SENSE: C8.1, R7.1, U1.36 (PF7), U3.6 (IS), U4.6 (IS)
/PROG: R14.2, U1.31 (PC6), U2.11
/PROG_EN: R13.2, R15.2, U1.12 (PB7)
/PROG_N: J12.1, U6.4 (OUT), U6.8 (OUT)
/PROG_P: J12.2, U5.4 (OUT), U5.8 (OUT)
/PROG_SENSE: C9.1, R8.1, U1.37 (PF6), U5.6 (IS), U6.6 (IS)
/RESET: J2.5 (~RST), R1.1, U1.13 (~RESET)
/SCK: J2.3 (SCK), U1.9 (PB1)
/TRACK_N: J11.1, U4.4 (OUT), U4.8 (OUT)
/TRACK_P: J11.2, U3.4 (OUT), U3.8 (OUT)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, D1.2, D2.2, J1.5 (GND), J1.6 (Shield), J2.6 (GND), J10.1, R6.1, R7.2, R8.2, R17.2, R18.2, R19.2, R20.2, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U2.1, U2.3, U2.5, U2.7 (GND), U2.9, U3.1 (GND), U4.1 (GND), U5.1 (GND), U6.1 (GND), Y1.2, Y1.4
unnamed: C4.1, U1.17 (XTAL1), Y1.1
unnamed: C5.1, U1.16 (XTAL2), Y1.3
unnamed: C6.2, U1.42 (AREF)
unnamed: C7.2, U1.6 (UCAP)
unnamed: C10.1, R17.1, U4.5 (SR)
unnamed: C11.1, R18.1, U5.5 (SR)
unnamed: C12.1, R19.1, U6.5 (SR)
unnamed: C13.1, R20.1, U3.5 (SR)
unnamed: D1.1, R4.1
unnamed: D2.1, R5.1
unnamed: F1.2, J1.1 (VBUS)
unnamed: J1.2 (D-), R3.2
unnamed: J1.3 (D+), R2.2
unnamed: R2.1, U1.4 (D+)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.2, U1.8 (PB0)
unnamed: R5.2, U1.22 (PD5)
unnamed: R6.2, U1.33 (~HWB~/PE2)
unnamed: R9.1, U3.3 (INH)
unnamed: R10.1, U3.2 (IN)
unnamed: R11.1, U4.3 (INH)
unnamed: R12.1, U4.2 (IN)
unnamed: R12.2, U2.12
unnamed: R13.1, U5.3 (INH)
unnamed: R14.1, U5.2 (IN)
unnamed: R15.1, U6.3 (INH)
unnamed: R16.1, U6.2 (IN)
unnamed: R16.2, U2.10
VCC: C14.1, C15.1, C16.1, C17.1, C18.1, J10.2, U3.7 (VS), U4.7 (VS), U5.7 (VS), U6.7 (VS)

Notes on the sheet:
Track Out
Power
Prog Out
Unused Inverters
TX LED
RX LED
Current Sense: Max current @ 10A load is 1.05mA ( 666uA load + 385 uA offset ) Fault current: 4.1 to 6.1mA Ok to sum currents from multiple devices. Current sense only when high side active. Fault current continuous.
Place 0.1uF decoupling caps near Vcc on U1 and U2
2.0

Board: 2 copper layers, 101.6 x 63.5 mm, 66 parts (0 on the bottom side), 59 nets.

## Commit log

2019-05-22 Fix ERC errors
2019-05-22 Add digital connectors. Fixes most remaining ERC
2019-05-22 Add symbol for IFX007T
2019-05-22 DCC++ PCB. ATMega32U4 + USB
2019-05-22 Add DCC++ pdf and current sense circuit
2019-05-22 Start assigning footprints and part numbers
2019-05-22 Add most output circuitry
2019-05-22 Arduino side complete
2019-05-22 More part numbers and footprints
2019-05-22 Assign most footprints
2019-05-22 Add datasheets and 5V
2019-05-22 Setup design rules
2019-05-22 More layout work
2019-05-22 PCB created, placement mostly complete
2019-05-22 Final part numbers
2019-05-22 Cleanup of h-bridge layout
2019-05-22 Remove ignored file
2019-05-22 Ignore fp-info-cache
2019-05-22 Start work on signal layout.
2019-05-23 More routing.
2019-05-24 More routing
2019-05-31 More layout
2019-06-02 Routing almost complete
2019-06-02 Routing complete
2019-06-02 Clean up silkscreen
2019-06-04 Add DCC logo
2019-06-12 Working on board art
2019-06-12 Locomotive art!
2019-06-12 Finished art
2019-06-12 Clean up DCC logo
2019-06-26 Fix crystal
2019-06-27 Add README
2020-05-18 Add IFX9201 datasheet, symbol and footprint
